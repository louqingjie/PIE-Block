# Keil uVision project Project_Template.uvproj, settings and files
target Project (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: Project_Template +hex
  group startup
    ../../../Libraries/startup/src/: common.c
    ../../../Libraries/startup/inc/: STC32Gxx.h common.h STC32_MDU32_LARGE_V1.1.LIB
  group user
    ../USER/src/: isr.c main.c
  group drivers
    ../../../Libraries/deivers/src/: CNU_PIE_GPIO.c CNU_PIE_TIMER.c CNU_PIE_UART.c STC32G_EEPROM.c iap_proto.c
    ../../../Libraries/deivers/inc/: CNU_PIE_GPIO.h CNU_PIE_TIMER.h CNU_PIE_UART.h STC32G_EEPROM.h iap_proto.h
