# Keil uVision project Project_Template.uvproj, settings and files
target Project (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: Project_Template +hex
  link misc: CLASSES (CODE (0xFF1003-0xFFFFFF))
  group startup
    ../../../Libraries/startup/src/: common.c
    ../../../Libraries/startup/inc/: STC32Gxx.h common.h STC32_MDU32_LARGE_V1.1.LIB
  group user
    ../USER/src/: isr.c main.c
  group boards
    ../../../Libraries/boards/src/: BMI088driver.c BMI088Middleware.c Encoder.c OLED.c LCD.c Font.c remote_control.c nrf24l01.c
  group drivers
    ../../../Libraries/deivers/src/: CNU_PIE_GPIO.c CNU_PIE_TIMER.c CNU_PIE_EXTI.c CNU_PIE_ADC.c CNU_PIE_I2C.c CNU_PIE_SPI.c CNU_PIE_PWM.c CNU_PIE_WDog.c CNU_PIE_UART.c CNU_PIE_FIFO.c
    ../../../Libraries/deivers/inc/: CNU_PIE_GPIO.h CNU_PIE_TIMER.h CNU_PIE_EXTI.h CNU_PIE_ADC.h CNU_PIE_I2C.h CNU_PIE_SPI.h CNU_PIE_PWM.h CNU_PIE_WDog.h CNU_PIE_UART.h CNU_PIE_FIFO.h
